# Keil uVision project test.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: test +hex
  c flags: Optim=1
  c include: .\Source\User\Main;.\Source\CMSIS\Core\CM3;.\Source\STM32F10x_StdPeriph_Driver\inc;.\Source\User\Usart;.\Source\User\Motor
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ./Source/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
    ./Source/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_hd.s
  group Main
    ./Source/User/Main/: main.c stm32f10x_it.c stm32f10x_conf.h usually.h
    ./Source/User/Usart/: usart.c
    ./Source/User/Motor/: motor.c
  group StdPeriph_Driver
    ./Source/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_gpio.c
  group Readme
    ./Source/User/Doc/: Readme.c
software components: CMSIS:CORE 4.3.0
